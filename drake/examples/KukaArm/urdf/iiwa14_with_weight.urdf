Commit message: Tweaks to KukaArm URDF

File: drake/examples/KukaArm/urdf/iiwa14_with_weight.urdf (robot description, URDF)
Before this commit: robot iiwa14, 12 links, 11 joints
Links:
- link world: mass None -> 0.01
